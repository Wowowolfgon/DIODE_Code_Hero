# Keil uVision project infantry_top.uvprojx, settings and files
target infantry_top (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F427IIHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF)  CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4")
  output: Template +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx,USE_HAL_DRIVER,STM32F427xx
  c include: ../Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc;       ../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;       ../Drivers/CMSIS/Device/ST/STM32F4xx/Include;       ../Drivers/CMSIS/Include;       ../Middlewares/Third_Party/FreeRTOS/Source/include;       ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;       ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;       .\Bsp\BSP_OLED;       .\Bsp\BSP_ADC;       .\Bsp\BSP_LED;       .\Bsp\BSP_CAN;       .\Bsp\BSP_IMU;       .\Bsp\BSP_PWR;       .\Control\PID;       .\Bsp\BSP_PWM;       .\Control\SHOOT;       .\Control\RC_CONTROL;       .\Control\Chassis;       .\Debug\DEBUG_OLED;       .\Bsp\BSP_RC;       .\Bsp\BSP_BEEP;       .\Bsp\BSP_TIM;       .\Debug\BLUETOOTH;       .\Debug\USMART;       .\Control\Gimbal;       .\Referee_system;       .\Judge;       .\SuperCapacitor;       .\Bsp\BSP_USART;       .\Bsp\BSP_BMI088
  asm include: ..\\Inc;..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f427xx.s
  group Application/User
    ../Src/: main.c gpio.c adc.c can.c dma.c freertos.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Bsp
    ./Bsp/BSP_ADC/: bsp_adc.c
    ./Bsp/BSP_TIM/: bsp_tim.c
    ./Bsp/BSP_USART/: bsp_usart.c
    ./Bsp/BSP_CAN/: bsp_can.c
    ./Bsp/BSP_PWM/: bsp_pwm.c
    ./Bsp/BSP_BEEP/: bsp_beep.c
    ./Bsp/BSP_LED/: bsp_led.c
    ./Bsp/BSP_PWR/: bsp_pwr.c
    ./Bsp/BSP_RC/: bsp_rc.c
    ./Bsp/BSP_BMI088/: BMI088driver.c BMI088Middleware.c
  group Control
    ./Control/PID/: pid.c
    ./Control/Chassis/: chassis.c
    ./Control/Gimbal/: gimbal.c
    ./Control/SHOOT/: shoot.c
    ./Control/RC_CONTROL/: rc_control.c
  group Debug
    ./Debug/BLUETOOTH/: bluetooth.c
    ./Debug/USMART/: usmart.c usmart_config.c usmart_str.c
  group Readme
    ./Doc/: Readme.txt
  group JudgeTask
    ./Judge/: JudgeTask.c
  group SuperCapacitor
    ./SuperCapacitor/: SuperCapacity.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 4.3.0
